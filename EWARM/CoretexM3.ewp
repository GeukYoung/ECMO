# IAR project CoretexM3.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZC ST STM32F103ZC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE; ARM_MATH_CM3
  ICCARM.CCIncludePath2: ..\App\; ..\App\Base; ..\App\Data; ..\App\Task; ..\App\Task\Control; ..\App\Task\SerialComm; ..\App\Util; ..\Boot; ..\Drivers; ..\Drivers\BSP; ..\Drivers\BSP\Flash; ..\Drivers\BSP\LED; ..\Drivers\BSP\IUART; ..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\Drivers\CMSIS\Include; ..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\Drivers\STM32F1xx_HAL_Driver\Src; ..\Middlewares\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\Middlewares\FreeRTOS\Source\CMSIS_RTOS; ..\Middlewares\FreeRTOS\Source\include; ..\Middlewares\FreeRTOS\Source\User
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Middlewares\FreeRTOS\Source\User
  ILINK.IlinkOutputFile: CoretexM3.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../App/: project.h Version.h
  group App/Base
    ../App/Base/: main.c startup_stm32f103xe.s stm32f1xx_hal_conf.h stm32f1xx_hal_timebase_tim.c stm32f1xx_it.c stm32f1xx_it.h system_stm32f1xx.c
  group App/Data
    ../App/Data/: AppData.c AppData.h AppParam.c AppParam.h
  group App/Task
    ../App/Task/: TaskInit.c TaskInit.h
  group App/Task/Control
    ../App/Task/Control/: ControlTask.c ControlTask.h Seq.c Seq.h
  group App/Task/SerialComm
    ../App/Task/SerialComm/: SerialComm.c SerialComm.h SerialCommTask.c SerialCommTask.h
  group App/Util
    ../App/Util/: Util.c Util.h
  group Boot
    ../Boot/: flash_if.c flash_if.h
  group Drivers/BSP
    ../Drivers/BSP/: ADC108S022.c ADC108S022.h Buzzer.c Buzzer.h DAC8568.c DAC8568.h DIO.c DIO.h II2C.c II2C.h ISPI.c ISPI.h ITIMER.c ITIMER.h IUART.c IUART.h LED.c LED.h MCP23S08.c MCP23S08.h
  group Drivers/STM32F1xx_HAL_Driver/Inc
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal.h stm32f1xx_hal_def.h stm32f1xx_hal_gpio.h stm32f1xx_hal_uart.h
  group Drivers/STM32F1xx_HAL_Driver/Src
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_fsmc.c
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../Middlewares/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.h
  group Middlewares/FreeRTOS/portable
    ../Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group Middlewares/FreeRTOS/User
    ../Middlewares/FreeRTOS/Source/User/: FreeRTOSConfig.h
